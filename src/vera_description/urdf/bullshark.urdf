Commit message: Seperated robot and host  domains

File: src/vera_description/urdf/bullshark.urdf (robot description, URDF)
Before this commit: robot bullshark, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://vera_description/models/meshes/base.dae
